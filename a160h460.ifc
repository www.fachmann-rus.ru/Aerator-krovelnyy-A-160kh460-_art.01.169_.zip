Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-22T16:42:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Alternate UI 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 22 16:42:46 2020 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{DCDBFB49-824F-4E30-8630-8500734BCB32}\ifc * Database version: 5507 * Database creation date: Tue Sep 22 16:42:44 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 22 16:42:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 22 16:42:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
Phase: П

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Категория: Сведения о проекте; Статус проекта: П

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Название организации: Название организации
Прочее - Категория: Сведения о проекте; Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Статус проекта: П

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcFlowTerminal: А160х460, BIMLIB_Аэратор_Fachmann_А160х460:А160х460:256896
In: Этаж 01
Material: Fachmann_ПВХ_Черный
Pset_ManufacturerTypeInformation - Manufacturer: Fachmann
Pset_DistributionFlowElementCommon - Reference: А160х460
Зависимости - Рабочая плоскость: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Отметка по умолчанию: 1219.2 mm
Идентификация - Марка: 25; ADSK_Версия семейства: 1; URL: https://fachmann-rus.ru/; Изготовитель: Fachmann; Имя типа: А160х460; Описание: Аэратор кровельный А 160х460 предназначен для воздухообмена и отвода водяных паров, для санации «дышащих» кровель, чем предотвращает образование вздутий на кровельном ковре и значительно увеличивает срок службы кровельного ковра. Аэратор оснащен колпаком, благодаря которому дождевая вода не попадает в конструкцию. Принцип действия этого аэратора основан на разнице давлений, вызванной воздушными потоками.; Производитель_Контакты: Email: all@fachmann-rus.ru; Тел: 8 (800) 511-07-21; Разработчик_Контакты: support@bimlib.pro
Прочее - Категория: Сантехнические приборы; Код типа: BIMLIB_Аэратор_Fachmann_А160х460: А160х460; Семейство: BIMLIB_Аэратор_Fachmann_А160х460: А160х460; Семейство и типоразмер: BIMLIB_Аэратор_Fachmann_А160х460: А160х460; Тип: BIMLIB_Аэратор_Fachmann_А160х460: А160х460; Уровень спецификации: Уровень: Этаж 01; d1: 145.7 mm; d2: 121.8 mm; Имя семейства: BIMLIB_Аэратор_Fachmann_А160х460
Размеры - Объем: 0.0117156 m3; ADSK_Диаметр условный: 160 mm; ADSK_Размер_Высота: 455 mm; D_Колпака: 210 mm; D_Юбки: 455 mm
Стадии - Стадия возведения: ПРОЕКТ
Данные - ADSK_URL документации изделия: https://kirov.fachmann-rus.ru/upload/iblock/1be/1bedcf4d647098ac3899c12b2077835f.pdf; ADSK_URL страницы изделия: https://kirov.fachmann-rus.ru/catalog/aeratory-deflektory-flugarki/396/; ADSK_Версия Revit: 2017; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: Fachmann; ADSK_Код изделия: 22.23.19.12.1.01.01; ADSK_Количество: 1; ADSK_Марка: A160х460; ADSK_Масса_Текст: 1,05 кг; ADSK_Наименование: Аэратор кровельный A160х460 (арт. 01.105); ADSK_Наименование краткое: Аэратор кровельный A1160х460
Текст - Fachmann_Артикул: 01.105; Fachmann_СрокСлужбы: не менее 50 лет; Fachmann_ТемператураОкружающейСреды: постоянная - от -40 °С до +80 °С; временная - от -55 °С до +120 °С
